# Keil uVision project 继电器控制实验.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0 - 0x7F) IROM(0 - 0xFFF) CLOCK(24000000)
  output: 继电器控制实验 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    C:/Documents and Settings/Administrator/桌面/新建文件夹/继电器控制实验/: STARTUP.A51
    ./: 继电器控制实验.asm
