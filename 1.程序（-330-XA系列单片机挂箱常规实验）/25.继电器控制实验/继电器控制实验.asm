JDQ EQU P1.1
ORG 0000H
LJMP MAIN
ORG 0003H
RETI
ORG 000BH
RETI
ORG 0013H
RETI
ORG 001BH
RETI
ORG 0023H
RETI
ORG 002BH
RETI
MAIN: SETB JDQ;
	LCALL DL1S
	CLR JDQ;
	LCALL DL1S
	JMP MAIN
    DL1S:MOV R5,#02H
  DL11S:MOV R6,#0FFH
   DD: MOV R7,#0FFH
       DJNZ R7,$
       DJNZ R6,DD
       DJNZ R5,DL11S
       RET
	END
